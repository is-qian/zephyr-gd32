## boards/gd32c231f8_dk/board.yml
```yaml
board:
  name: gd32c231f8_dk
  full_name: GD32C231F8-DK
  vendor: gd
  socs:
    - name: gd32c231
```
